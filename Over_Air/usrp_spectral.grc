options:
  parameters:
    author: John Sylvia
    generate_options: qt_gui
    id: usrp_sprectral_analysis
    output_language: python
    title: USRP Spectral Analysis
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0)
    label: Bandwidth
    start: '0'
    step: '1'
    stop: '1000'
    value: '100'
  states: {}
- name: center
  id: variable
  parameters:
    value: 2.437e9
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    label: Center Frequency
    start: '0'
    step: '1'
    stop: '20000'
    value: '1000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0]'
    label: Gain (dB)
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: variable_band_pass_filter_taps_0
  id: variable_band_pass_filter_taps
  parameters:
    gain: 10**(gain/10)
    high_cutoff_freq: center_freq+bandwidth/2
    low_cutoff_freq: center_freq-bandwidth/2
    samp_rate: samp_rate
    type: band_pass
    width: bandwidth/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '5000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: variable_band_pass_filter_taps_0
    type: ccc
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '1024'
    name: '"Analysis"'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
