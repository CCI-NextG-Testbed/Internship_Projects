options:
  parameters:
    author: John Sylvia
    generate_options: qt_gui
    id: tv_receiver
    output_language: python
    title: TV Receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1e6
    step: 200e3
    stop: 1000e6
    value: 608.31e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: samp_rate
    sps: '1.1'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 6e6
    center_freq0: freq
    dev_addr: '"addr=192.168.10.2"'
    gain0: '30'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [dtv_atsc_rx_0, '0', network_udp_sink_0, '0']
- [uhd_usrp_source_0, '0', dtv_atsc_rx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
